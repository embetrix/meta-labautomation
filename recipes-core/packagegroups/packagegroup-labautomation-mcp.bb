SUMMARY = "Robot Framework MCP integration"
LICENSE = "MIT"

inherit packagegroup

RDEPENDS:${PN} = " \
    python3-robotframework-mcp \
"
