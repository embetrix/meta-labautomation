do_install:append() {
    install -d ${D}${localstatedir}/lib/docker
}
