RDEPENDS:${PN}:append = " \
    python3-labgrid-mcp \
    python3-labgrid-plugins \
"
