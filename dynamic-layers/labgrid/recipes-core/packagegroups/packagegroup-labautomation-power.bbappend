RDEPENDS:${PN}:append = " \
    python3-powerrelay \
    python3-labgrid-fritz \
    python3-usbsdmux \
"
