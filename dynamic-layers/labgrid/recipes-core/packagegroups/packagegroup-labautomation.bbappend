RDEPENDS:${PN}:append = " packagegroup-labautomation-labgrid"
