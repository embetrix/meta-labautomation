# Labgrid plugins use the iio Python module
PACKAGECONFIG:append = " libiio-python3"
