SUMMARY = "Object-oriented paths"
HOMEPAGE = "https://github.com/p1c2u/pathable"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=86d3f3a95c324c9479bd8986968f4327"

inherit pypi python_poetry_core

SRC_URI[sha256sum] = "6404b8b82aef5ff0fd478934137128b99b12212ba35afdde5525ca4f8388ea58"
