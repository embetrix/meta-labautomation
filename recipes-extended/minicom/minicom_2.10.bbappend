FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-src-sysdep.h-remove-cfset-i-o-speed-macros-for-glibc.patch"
